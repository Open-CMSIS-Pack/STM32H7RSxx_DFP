# Keil uVision project STM32H7S38_NUCLEO.uvprojx, settings and files
target STM32H7S38_NUCLEO_OSPI (6190000::V6.19::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: MX25UW25645G_STM32H7S38-NUCLEO
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=2 uC99=1
  c define: FLASH_MEM,USE_HAL_DRIVER,USE_IOEXPANDER, CORE_CM7,STM32H7S3xx
  c include: .\OSPI;..\..\Flash;..\..\..\Drivers\BSP\Components;..\..\..\Drivers\BSP\STM32H7S78-DK;..\..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include;..\..\..\Drivers\CMSIS\Core\Include;..\..\..\Drivers\BSP\Components\aps256xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group OSPI
    ./OSPI/: STM32H7RSOSPI.c
    ../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c
    ../../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
    ../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
