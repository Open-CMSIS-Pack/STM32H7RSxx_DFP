# Keil uVision project STM32H7Rx-7Sx.uvprojx, settings and files
target STM32H7Rx-7Sx_64 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: STM32H7Rx_64k
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=4 uC99=1 wLevel=2
  c define: FLASH_MEM,
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
