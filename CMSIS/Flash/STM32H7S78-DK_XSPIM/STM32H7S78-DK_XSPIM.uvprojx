# Keil uVision project STM32H7S78-DK_XSPIM.uvprojx, settings and files
target STM32H7S78-DK-XSPIM1 (6210000::V6.21::ARMCLANG)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: MX66UW1G45G_STM32H7S78-DK-XSPIM1
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=2 uC99=1
  c define: FLASH_MEM,USE_HAL_DRIVER,STM32H7B0xxQ,USE_IOEXPANDER, CORE_CM7,STM32H7S7xx
  c include: ./;.\OSPI;..\..\..\Drivers\BSP\Components;..\..\..\Drivers\CMSIS\Core\Include;..\..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include;..\..\..\Drivers\STM32H7rsxx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32H7S78-DK
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x24000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group OSPI
    ./OSPI/: STM32H7OSPI.c
    ../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c
    ../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
    ../../../Drivers/BSP/STM32H7S78-DK/: stm32h7s78_discovery_xspi.c
    ../../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
    ../../../Drivers/BSP/Components/aps256xx/: aps256xx.c
    ./: startup_stm32h7s7xx.s FlashTest.c
software components: CMSIS:CORE 5.6.0
